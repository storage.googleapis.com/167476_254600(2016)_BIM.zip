Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2019-08-23T10:51:56
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190508_0315(x64) - Exporter 17.4.0.0 - Alternate UI 17.4.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Aug 23 10:51:56 2019 * Host: Avocado-PC * Database: C:\Users\Avocado\AppData\Local\Temp\{4D72E51A-3359-43A3-837D-A0BD8CD9DB5A}\ifc * Database version: 5507 * Database creation date: Fri Aug 23 10:51:55 2019 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Fri Aug 23 10:51:55 2019 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Aug 23 10:51:55 2019 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFlowController: 254600 Shower rail, 254600(2016):254600 Shower rail:428005
In: Level 1
Type - PredefinedType: FAUCET
Type - Dimensions(Type) - NominalDepth: 104.933 mm; NominalHeight: 763.141 mm; NominalWidth: 222.173 mm
Type - General(Type) - Author: Convergo AB; BIMObjectName: 254600(2016); ConvergoRefNr: 0087-1909-0099-FI; ManufacterURL: http://www.oras.com/; ManufacturerName: Oras; NBSDescription: Water supply fittings for baths; NBSReference: 45-35-70/315; ProductInformation: n/a; Revision: n/a; Uniclass2: Pr_40_20_97_78; Uniclass2015Description: Shower manual water supply sets; Uniclass2015Reference: Pr_40_20_87_78; Version: 1; VersionDate: 24/07/2019
Type - Green Building Properties(Type) - Customs Code: 84819000; EAN Number: 6414150076268; LVI Number: 6510174; NRF Number: 4205136; RSK Number: 8284741; VVS Number: 737758004
Type - Identity Data(Type) - 2D/3D/BIM Files URL: http://static.oras.com/bim/254600; Catalog Drawing URL: http://static.oras.com/catdrw/254600; Dimension Drawing URL: http://static.oras.com/dimdrw/254600; FDV Document URL: http://www.oras.com/datasheet/254600/en/fdv; Group: Shower accessories; Long Marketing: Oras Apollo shower rail including adjustable installation elements, max. Length 720 mm; Manufacturer: Oras; Market: INT;FIN;NOR;SWE;DNK;POL;RUS;EST;LTU;LVA;UKR; Model: 254600 Shower rail; Name_en: 254600 Shower rail; OmniClass Number: 23.45.55.00; OmniClass Title: Sanitary Faucets, Wastes; Package external Dimensions: n/a; Package Weight: 0.550 kg; Product Code: 254600; Product Datasheet: http://www.oras.com/datasheet/254600/en; Product Family: Oras Apollo; Product Image URL: http://static.oras.com/image/254600; Product URL: http://static.oras.com/254600; Type Name: 254600 Shower rail
Type - Materials and Finishes(Type) - FaucetMainMaterial: Brass
Type - Mechanical(Type) - Installation and Maintenance: http://static.oras.com/manual/254600; Spare Parts: http://static.oras.com/sp/254600
Type - Other(Type) - Category: Plumbing Fixtures; AccessibilityPerformance: n/a; AssetType: Fixed; Brand: Oras; CodePerformance: n/a; Color: Chrome; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: 254600(2016); Features: n/a; Finish: Polished; Grade: n/a; Material: Brass; ModelNumber: n/a; ModelReference: 254600; Name: 254600 Shower rail; ReplacementCost: n/a; Shape: Sculptured; Size: 220x105x765 mm; SustainabilityPerformance: n/a; WarrantyDescription: http://warranty.oras.com; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Pset_ManufacturerTypeInformation - ModelReference: 254600; Manufacturer: Oras
Pset_DistributionFlowElementCommon - Reference: 254600 Shower rail
Constraints - DefaultElevation: 900 mm; Host: Level : Level 1; Level: Level: Level 1; Moves With Nearby Elements: no; Offset: 0 mm
Dimensions - Area: 0.272941 m2; Volume: 0.0177913 m3
Identity Data - Mark: 2
Other - AssetIdentifier: n/a; Barcode: n/a; Category: Plumbing Fixtures; Family: 254600(2016): 254600 Shower rail; Family and Type: 254600(2016): 254600 Shower rail; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: 254600(2016): 254600 Shower rail; Type Id: 254600(2016): 254600 Shower rail; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
